RDEPENDS:packagegroup-base-extended:remove = "packagegroup-base-3g packagegroup-base-nfc"
